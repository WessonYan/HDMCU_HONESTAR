<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC_Scan_TwochPollingSw_InOrder.ewp</path>
  </project>
  <batchBuild/>
</workspace>


