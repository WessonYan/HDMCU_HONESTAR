<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ct_rt_iomode4.ewp</path>
  </project>
  <batchBuild/>
</workspace>


