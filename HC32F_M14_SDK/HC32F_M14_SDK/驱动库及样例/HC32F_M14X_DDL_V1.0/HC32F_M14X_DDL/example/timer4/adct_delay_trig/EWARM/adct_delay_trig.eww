<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\adct_delay_trig.ewp</path>
  </project>
  <batchBuild/>
</workspace>


