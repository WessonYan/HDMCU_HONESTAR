# Keil uVision project pwm_dead_timer_filter_mode.uvprojx, settings and files
target pwm_dead_timer_filter_mode_Release (5060020::V5.06 (build 20)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: pwm_dead_timer_filter_mode
  c flags: Optim=1 OneElfS=1
  c misc: --diag_suppress=186
  c include: ..\..\..\..\mcu\common;..\source;..\..\..\..\driver\inc
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x1800
  link misc: --keep=*Handler
  group common
    ./: startup_hc32f_m14x.s
    ../../../../mcu/common/: system_hc32f_m14x.c
  group source_files
    ../source/: main.c
  group driver
    ../../../../driver/src/: ddl.c interrupts_hc32f_m14x.c clk.c gpio.c timer4_cnt.c timer4_oco.c timer4_pwm.c
software components: CMSIS:CORE 4.1.0
