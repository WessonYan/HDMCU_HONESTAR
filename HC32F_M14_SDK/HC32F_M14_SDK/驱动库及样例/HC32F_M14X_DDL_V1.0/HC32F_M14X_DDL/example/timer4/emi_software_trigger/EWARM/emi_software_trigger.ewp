# IAR project emi_software_trigger.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: __DEBUG
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: emi_software_trigger.srec
  ILINK.IlinkOutputFile: emi_software_trigger.out
  ILINK.IlinkIcfFile: hc32f_m14x.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration debug (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\mcu\common; ..\source; ..\..\..\..\driver\inc; ..\..\..\..\utility
  group common
    ../../../../mcu/common/: system_hc32f_m14x.c
    ./: startup_hc32f_m14x.s
    ../../../../driver/src/: ddl.c interrupts_hc32f_m14x.c
  group driver
    ../../../../driver/src/: gpio.c clk.c timer4_cnt.c timer4_oco.c timer4_pwm.c timer4_emi.c
  group source
    ../source/: main.c
